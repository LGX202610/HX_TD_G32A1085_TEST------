# IAR project G32A1065_BootLoader.ewp, settings and files
configuration G32A1065 (ARM, debug)
  General.OGChipSelectEditMenu: G32A1065 Geehy G32A1065
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; G32A10xx; G32A1065; START_FROM_FLASH; TURN_ON_CPU0; UDS_PROJECT_FOR_BOOTLOADER; AUTOSAR_OS_NOT_USED
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\Device\include; ..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\..\..\Driver\include; ..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\lin; ..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\..\..\Uds\Port\inc; ..\..\..\..\Hal\include; ..\..\..\..\Hal\include; ..\..\..\..\Hal\include; ..\..\..\..\Hal\include; ..\..\..\..\Uds\Verify\inc; ..\..\..\..\Hal\include; ..\..\..\..\Uds\Port\inc; ..\..\..\..\Uds\auto_lib\inc; ..\..\..\..\Application\include; ..\..\..\..\Uds\FIFO\inc; ..\..\..\..\Uds\Flash\inc; ..\..\..\..\Uds\TP\inc; ..\..\LIN_TP\inc; ..\..\..\..\Uds\UDS\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: START_FROM_FLASH; TURN_ON_CPU0; UDS_PROJECT_FOR_BOOTLOADER
  AARM.AUserIncludes: SEGGER_RTT\include
  OBJCOPY.OOCOutputFile: UDS_G32A1065_Bootloader.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.elf
  ILINK.IlinkIcfFile: ..\..\..\..\Libraries\Device\iar\iar_flash_g32a1065_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AUTOSAR_OS_NOT_USED; IAR; G32A1065
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\Platform_TS_T23D06M1I0R0\include; ..\..\..\Det_TS_T23D06M1I0R0\include; ..\..\..\Rte_TS_T23D06M1I0R0\include; ..\..\..\Dem_TS_T23D06M1I0R0\include; $TOOLKIT_DIR$\CMSIS\Core\Include; ..\..\..\Port_TS_T23D06M1I0R0\include; ..\..\..\Dio_TS_T23D06M1I0R0\include; ..\..\..\Mcu_TS_T23D06M1I0R0\include; Application\include; ..\..\..\Platform_TS_T23D06M1I0R0\startup\include; Config\include; ..\..\..\Pdl_TS_T23D06M1I0R0\include
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Adc_ITA.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\Platform_TS_T23D06M1I0R0\Startup\link\autosar_flash_g32a1465.icf
  ILINK.IlinkProgramEntryLabel: _start
  group Application
    Application/src/: main.c
  group Platform
    ../../../../Libraries/Device/source/: startup_g32a10xx_iar.s system_g32a10xx.c
  group Sdk
    ../../../../Driver/source/: flash.c
    ../../../../Libraries/G32A10xx_StdPeriphDriver/src/: g32a10xx_fls.c g32a10xx_gpio.c g32a10xx_int.c g32a10xx_iwdt.c g32a10xx_misc.c g32a10xx_rcm.c g32a10xx_tmr.c g32a10xx_usart.c
    ../../lin/: lin_app.c
  group Uds_PortingFiles/Boot
    ../../../../Uds/Port/src/: boot.c boot_Cfg.c
  group Uds_PortingFiles/Debug
    ../../../../Hal/source/: bootloader_debug.c debug_IO.c debug_timer.c
  group Uds_PortingFiles/Hal/Crc_Hal
    ../../../../Hal/source/: CRC_hal.c
  group Uds_PortingFiles/Hal/Flash_Hal
    ../../../../Hal/source/: flash_hal.c flash_hal_Cfg.c
  group Uds_PortingFiles/Hal/Timer_Hal
    ../../../../Hal/source/: timer_hal.c
  group Uds_PortingFiles/Hal/Uds_Algorithm_Hal
    ../../../../Uds/Verify/src/: AES.c UDS_alg_hal.c ZLGKey.c
  group Uds_PortingFiles/Hal/Watchdog_Hal
    ../../../../Hal/source/: watchdog_hal.c
  group Uds_Stack/Auto_Lib
    ../../../../Uds/auto_lib/src/: autolibc.c
  group Uds_Stack/Demo
    ../../../../Application/source/: bootloader_main.c
  group Uds_Stack/Fifo
    ../../../../Uds/FIFO/src/: multi_cyc_fifo.c
  group Uds_Stack/Flash_App
    ../../../../Uds/Flash/src/: fls_app.c
  group Uds_Stack/Lin_Tp
    ../../LIN_TP/src/: LIN_tp.c LIN_tp_cfg.c
    ../../../../Uds/TP/src/: TP.c TP_Cfg.c
  group Uds_Stack/Uds
    ../../../../Uds/UDS/src/: uds_app.c uds_app_cfg.c
