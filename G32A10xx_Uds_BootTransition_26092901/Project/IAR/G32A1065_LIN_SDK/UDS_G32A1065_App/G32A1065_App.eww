<?xml version="1.0" encoding="UTF-8"?>
<workspace>
     <project>
        <path>$WS_DIR$\G32A1065_App.ewp</path>
    </project>
    <batchBuild />
</workspace>
