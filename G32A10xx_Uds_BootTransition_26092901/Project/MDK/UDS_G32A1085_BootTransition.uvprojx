# Keil uVision project UDS_G32A1085_BootTransition.uvprojx, settings and files
target G32A1085 (6160000::V6.16::ARMCLANG)
  device: G32A1085MAT0MLHx Geehy
  pack: Geehy.G32A10xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x0800F800,0x00016E00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UDS_G32A1085_BootTransition +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: G32A1085,G32A10xx,G32A10x_SERIES,START_FROM_FLASH,TURN_ON_CPU0,UDS_PROJECT_FOR_BOOTLOADER
  c misc: -fno-inline
  c include: ..\..\Application\include;..\..\Driver\include;..\..\Hal\include;..\..\Libraries\CMSIS\Include;..\..\Libraries\Device\include;..\..\Libraries\G32A10xx_StdPeriphDriver\inc;..\..\Uds\auto_lib\inc;..\..\Uds\FIFO\inc;..\..\Uds\Flash\inc;..\..\Uds\Port\inc;..\..\Uds\TP\inc;..\..\Uds\UDS\inc;..\..\Uds\Verify\inc
  asm define: UDS_PROJECT_FOR_BOOTLOADER
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8040000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\mdk_flash_g32a1085_bootloader.sct
  link misc: --diag_suppress=6314
  group Application
    ../../Application/source/: main.c bootloader_main.c
  group Startup
    ../../Libraries/Device/source/: system_g32a10xx.c startup_g32a10xx_mdk.s
  group Driver
    ../../Driver/source/: user_can_config.c can_cfg.c can_driver.c flash.c
  group Hal
    ../../Hal/source/: bootloader_debug.c debug_IO.c debug_timer.c CRC_hal.c flash_hal.c flash_hal_Cfg.c timer_hal.c watchdog_hal.c
  group Libraries
    ../../Libraries/G32A10xx_StdPeriphDriver/src/: g32a10xx_can.c g32a10xx_fls.c g32a10xx_gpio.c g32a10xx_int.c g32a10xx_misc.c g32a10xx_rcm.c g32a10xx_tmr.c g32a10xx_usart.c g32a10xx_iwdt.c
  group Uds_Port
    ../../Uds/Port/src/: boot.c boot_Cfg.c
  group Uds_FIFO
    ../../Uds/FIFO/src/: multi_cyc_fifo.c
  group Uds_Flash
    ../../Uds/Flash/src/: fls_app.c
  group Uds_TP
    ../../Uds/TP/src/: TP.c TP_Cfg.c can_tp.c can_tp_cfg.c
  group Uds_UDS
    ../../Uds/auto_lib/src/: autolibc.c
    ../../Uds/UDS/src/: uds_app.c uds_app_cfg.c uds_dtc_nvm.c user_versions.c
  group Uds_Verify
    ../../Uds/Verify/src/: AES.c UDS_alg_hal.c ZLGKey.c bn.c sha256.c x509.c uds_verify.c
