#include "uds_verify.h"
#include "api.h"
#include "bn.h"
#include "fls_app.h"
#include "uds_dtc_nvm.h"
#include "flash.h"

// ★ CA公钥：从《生产环境package-CA公钥.pdf》中提取
// 默认的 E 值为 65537
const uint8_t g_ca_public_key[256] = 
{0xb9,0x3e,0x67,0x7c,0x8c,0x86,0x15,0x3d,0xdc,0x66,0x14,0x0c,0xaa,0x05,0x94,0xd8,
0x67,0x05,0xd5,0x86,0x64,0x34,0x39,0x8e,0x92,0xc3,0xa0,0x9c,0x5c,0x98,0xd1,0x55,
0x0b,0x02,0x5c,0x8b,0xe5,0x86,0xed,0x1f,0x8b,0xde,0xc2,0x17,0x03,0x16,0x7a,0x2a,
0xd2,0x53,0x9a,0x5f,0x13,0xec,0xeb,0x5d,0xcd,0xd8,0xed,0xb0,0xbe,0x01,0xeb,0x42,
0xe3,0x47,0xd2,0x8d,0xa8,0x94,0xed,0x5f,0xaa,0x5b,0xc0,0x9d,0x79,0xf0,0xb4,0x84,
0xd4,0x17,0x39,0x75,0x85,0x0f,0x29,0xd3,0xbd,0xed,0x71,0xdf,0x19,0x69,0x41,0x9a,
0xed,0xbe,0xcd,0xac,0xf2,0x04,0x84,0x51,0x05,0x72,0x22,0x02,0xea,0x18,0x28,0xca,
0x3b,0x70,0x8b,0x75,0x0c,0x9e,0xf0,0xb9,0x3d,0x6d,0x47,0xb6,0xee,0x84,0xee,0x0d,
0xe9,0x13,0x20,0xdf,0x38,0xf6,0xad,0xce,0xfd,0xb0,0xc0,0xf7,0x2d,0xea,0x94,0x91,
0x96,0x47,0xc4,0x86,0xd1,0x98,0xef,0x06,0x55,0xbc,0xc5,0xd5,0x62,0xd3,0x64,0x92,
0x50,0x10,0x65,0xe7,0xaf,0xdc,0xf9,0x5c,0x55,0x8a,0xf2,0x92,0x0f,0xec,0xea,0xb6,
0x64,0xc9,0x3f,0xcd,0xb4,0x72,0xeb,0x87,0xd7,0x8e,0x6b,0x0d,0x35,0x04,0xf8,0xe4,
0xbd,0x32,0xb1,0xdd,0xda,0x6c,0xb7,0x1d,0x9f,0xa2,0xdc,0x43,0xc2,0x0b,0x5c,0x0c,
0x16,0x11,0x55,0x65,0x04,0x80,0xf0,0x0e,0xfc,0xcf,0x0c,0x7b,0x56,0x20,0x4a,0xfb,
0x9e,0xfa,0x48,0xa2,0x77,0x3a,0x0d,0x9b,0x13,0x02,0x56,0xaf,0x7a,0x59,0x29,0x6d,
0x83,0x21,0x83,0xff,0x7e,0x1b,0xed,0x1e,0x05,0xd3,0x17,0xb7,0xa0,0x0c,0x18,0xbf,
};

/* 摘要值保存在 RAM 中（供后续 0x31 0x0203 使用） */
static uint8_t g_download_digest[32] = {0};
static uint8_t g_digest_valid = 0;

/* 版本信息保存在 RAM 中（供后续 0x31 0x6001 版本校验使用） */
static uint8_t g_download_version[10] = {0};
static uint8_t g_version_valid = 0;

//  * 2. 校验参数结构体（1322字节）（上位机通过0x31 0x6000发来1322字节）
typedef struct {
    uint8_t data_digest[32];        // 模块数据摘要值 (SHA256)
    uint8_t certificate[1024];       // X.509证书
    uint8_t version_info[10];       // 版本信息
    uint8_t signature[256];         // 刷写文件头信息签名值
} UDS_VerifyParamType;  // 总计: 32 + 1024 + 10 + 256 = 1322字节
/**
 * @brief 验证文件合法性（0x31 0x6000）
 * @param pParam 1322字节校验参数（上位机通过 0x31 0x6000 发来）
 *               数据结构：SHA256(32) + X.509(1024) + SW Version(10) + File signature(256)
 * @return 0=通过，-1=证书无效，-2=签名无效
 */
int UDS_Verify_CheckFileValidity(const uint8_t *pParam)
{
     /*============================================================
      * 1. 从1322字节数据中提取各部分（按结构图顺序）
      *    数据结构：SHA256(32) + X.509(1024) + SW Version(10) + File signature(256)
      *============================================================*/
     const uint8_t *data_digest = &pParam[0];      // SHA256 (Program Data)  32字节
     const uint8_t *certificate = &pParam[32];     // X.509 证书              1024字节
     const uint8_t *version_info = &pParam[1056];  // SW Version             10字节
     const uint8_t *file_signature = &pParam[1066];// File signature         256字节
     
     rsa_pk_t ca_pk = {0};
     rsa_pk_t cert_pk = {0};
     cont sig = {0};
     cont hash = {0};
     cont m = {0};
     cont e = {0};
     
     uint8_t dec_sign[256] = {0};
     uint8_t sha256_calc[32] = {0};
     uint32_t dec_sign_len = 0;
     struct sha256_ctx ctx = {0};
     int err = 0;
     
     UDSCFGDebugLog("0x31 0x6000 Verify start\n");
     UDSCFGDebugLog("data:SHA256(32) + X.509(1024) + SW Version(10) + File signature(256)\n");
     /*============================================================
      * 子步骤1：验证证书合法性
      * 使用 CA 公钥解密 X.509 证书中的 signatureValue
      *============================================================*/
     UDSCFGDebugLog("STEP1 Verify Cert\n");
     UDSCFGDebugLog("------------------------------------------------------------\n");
     
     /* 1.1 计算证书 TBS 的 SHA256 */
     err = calc_cert_sha256(certificate, 1024, sha256_calc);
     if (err != 0) {
         UDSCFGDebugLog("calc_cert_sha256 fail\n");
         return -1;
     }
     UDSCFGDebugLog("1.1 TBSCertificate SHA256 calc OK\n");
     
     /* 1.2 从证书中提取 signatureValue */
     err = get_x509_signature(certificate, 1024, &sig);
     if (err != 0) {
         UDSCFGDebugLog("get_x509_signature fail\n");
         return -1;
     }
     UDSCFGDebugLog("1.2 get signatureValue OK. len: %x byte\n", sig.len);
     
     /* 1.3 用 CA 公钥解密证书签名值 */
     ca_pk.bits = 2048;
     memcpy(ca_pk.m, g_ca_public_key, 256);
     /* CA 公钥指数为 65537 (0x10001) */
     ca_pk.e[253] = 0x01;
     ca_pk.e[254] = 0x00;
     ca_pk.e[255] = 0x01;
     
     err = rsa_public_decrypt(dec_sign, &dec_sign_len, (uint8_t *)sig.addr, sig.len, &ca_pk);
     if (err != 0) {
         UDSCFGDebugLog("rsa_public_decrypt fail: 0x%04x\n", err);
         return -1;
     }
     UDSCFGDebugLog("1.3  CA public key ok,len: %d byte\n", dec_sign_len);
     
     /* 1.4 从解密后的签名中提取哈希值 */
     err = get_hash_from_signature(dec_sign, dec_sign_len, &hash);
     if (err != 0) {
         UDSCFGDebugLog("get_hash_from_signature fail\n");
         return -1;
     }
     UDSCFGDebugLog("1.4 form jiemi get sha256 OK\n");
     
     /* 1.5 比对哈希值，验证证书是否由 CA 签发 */
     if (memcmp(hash.addr, sha256_calc, 32) != 0) {
         UDSCFGDebugLog("1.5  sha256 comp fail\n");
         return -1;  /* 证书无效 */
     }
     UDSCFGDebugLog("1.5  sah256 ok cert ok ca key ok\n\n");
     
     /*============================================================
      * 子步骤2：验证文件头签名
      * 使用证书公钥解密文件头签名值
      *============================================================*/
     UDSCFGDebugLog("STEP2 Verify hand\n");
     UDSCFGDebugLog("------------------------------------------------------------\n");
     
     /* 2.1 从证书中提取公钥 */
     err = get_x509_pkey(certificate, 1024, &m, &e);
     if (err != 0) {
         UDSCFGDebugLog("get_x509_pkey fail\n");
         return -2;
     }
     UDSCFGDebugLog("2.1 get_x509_pkey ok,m.len=%d, e.len=%d\n", m.len, e.len);
     
     /* 2.2 构造证书公钥 */
     cert_pk.bits = 2048;
     memcpy(cert_pk.m, m.addr, m.len);
     memcpy(&cert_pk.e[RSA_MAX_MODULUS_LEN - e.len], e.addr, e.len);
     UDSCFGDebugLog("2.2 Certificate Public Key OK\n");
     
     /* 2.3 计算 (data_digest + certificate + version_info) 的 SHA256 */
     SHA256_init(&ctx);
     SHA256_update(&ctx, data_digest, 32);
     SHA256_update(&ctx, certificate, 1024);
     SHA256_update(&ctx, version_info, 10);
     memcpy(sha256_calc, SHA256_final(&ctx), 32);
     UDSCFGDebugLog("2.3 calu Abstract + Certificate + Version SHA256 OK\n");
     
     /* 2.4 用证书公钥解密文件头签名值 */
     err = rsa_public_decrypt(dec_sign, &dec_sign_len, (uint8_t *)file_signature, 256, &cert_pk);
     if (err != 0) {
         UDSCFGDebugLog("rsa_public_decrypt fail: 0x%04x\n", err);
         return -2;
     }
     UDSCFGDebugLog("2.4 zhengshu jimi OK,len: %d byte\n", dec_sign_len);
     
     /* 2.5 从解密后的签名中提取哈希值 */
     err = get_hash_from_signature(dec_sign, dec_sign_len, &hash);
     if (err != 0) {
         UDSCFGDebugLog("get_hash_from_signature fail\n");
         return -2;
     }
     UDSCFGDebugLog("2.5 get_hash_from_signature OK\n");
     
     /* 2.6 比对哈希值，验证文件头签名 */
     if (memcmp(hash.addr, sha256_calc, 32) != 0) {
         UDSCFGDebugLog("2.6  Hash values do not match!Invalid signature !\n");
         return -2;  /* 签名无效 */
     }
     UDSCFGDebugLog("2.6  Hash value matching !Verify OK\n\n");
     
     /* ★ 保存摘要值到 RAM（供后续 0x31 0x0203 使用） */
     memcpy(g_download_digest, data_digest, 32);
     g_digest_valid = 1;
     UDSCFGDebugLog("sha256 saved to RAM\n");

     /* ★ 保存版本信息到 RAM（供后续 0x31 0x6001 版本校验使用） */
    memcpy(g_download_version, version_info, 10);
    g_version_valid = 1;
    UDSCFGDebugLog("version saved RAM: %.10s\n", g_download_version);

     /*============================================================
      * 最终结果
      *============================================================*/
     UDSCFGDebugLog("============================================================\n");
     UDSCFGDebugLog(" Verify successful!\n");
     UDSCFGDebugLog("============================================================\n");
     
     return 0;  /* 验签成功 */
 }

/* ================================================================
 * 获取保存的摘要值
 * ================================================================ */
uint8_t* UDS_Verify_GetSavedDigest(void)
{
    return (g_digest_valid) ? g_download_digest : NULL;
}
/**
 * @brief 获取保存的版本信息
 * @return 版本信息指针，无效时返回 NULL
 */
 uint8_t *UDS_Verify_GetSavedVersion(void)
 {
     return (g_version_valid) ? g_download_version : NULL;
 }
/* ================================================================
 * 清空摘要值
 * ================================================================ */
void UDS_Verify_ClearDigest(void)
{
    memset(g_download_digest, 0, 32);
    g_digest_valid = 0;
}
/**
 * @brief 清空版本信息
 */
 void UDS_Verify_ClearVersion(void)
 {
     memset(g_download_version, 0, 10);
     g_version_valid = 0;
 }

/* ================================================================
 * 检查已下载数据完整性（0x31 0x0203）
 * ================================================================ */
int UDS_Verify_CheckDownloadedData(void)
{
    uint8_t* pDigest;
    uint8_t calc_hash[32] = {0};
    struct sha256_ctx ctx;
    uint32_t total_len = 0;
    uint32_t segment_count = 0;
    uint32_t i = 0;
    uint32_t addr = 0;
    uint32_t len = 0;
    
    UDSCFGDebugLog("0x0203: Start data integrity check\n");
    {
        const uint8_t *pBak = Flash_GetUnrelocatedDriver();
        if (NULL != pBak)
        {
            UDSCFGDebugLog("drv bak head16: %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X %02X\r\n",
                           pBak[0], pBak[1], pBak[2], pBak[3],
                           pBak[4], pBak[5], pBak[6], pBak[7],
                           pBak[8], pBak[9], pBak[10], pBak[11],
                           pBak[12], pBak[13], pBak[14], pBak[15]);
        }
        else
        {
            UDSCFGDebugLog("drv bak missing\r\n");
        }
    }
    
    // 1. 获取验签时保存的摘要值
    pDigest = UDS_Verify_GetSavedDigest();
    if (pDigest == NULL) {
        UDSCFGDebugLog("0x0203: No digest saved! Verify first.\n");
        return -1;
    }
    
    // 2.  通过接口获取分段数量
    segment_count = UDS_APP_GetDownloadSegmentCount();
    if (segment_count == 0) {
        UDSCFGDebugLog("0x0203: No data downloaded!\n");
        return -1;
    }
    
    UDSCFGDebugLog("0x0203: Total segments = %d\n", segment_count);
    
    // 3. 计算所有已下载数据的 SHA256（按顺序累加）
    SHA256_init(&ctx);
    
    for (i = 0; i < segment_count; i++)
    {
        // 通过接口获取每个分段的信息
        if (UDS_APP_GetDownloadSegmentInfo(i, &addr, &len) != TRUE) {
            UDSCFGDebugLog("0x0203: Failed to get segment[%d]\n", i);
            continue;
        }
        
        UDSCFGDebugLog("  Segment[%d]: addr=0x%08X, len=%x\n", i, addr, len);
        
        if (addr != 0 && len > 0) {
            const uint8_t *pHash = (const uint8_t *)addr;
            if ((addr >= FLS_DRV_BEGIN_ADDR) && (addr < FLS_DRV_END_ADDR))
            {
                const uint8_t *pBak = Flash_GetUnrelocatedDriver();
                uint32_t off = addr - FLS_DRV_BEGIN_ADDR;
                if ((NULL == pBak) || ((off + len) > Flash_GetUnrelocatedDriverMaxSize()))
                {
                    UDSCFGDebugLog("0x0203: driver backup invalid\n");
                    return -1;
                }
                pHash = pBak + off;
            }
            SHA256_update(&ctx, pHash, len);
            total_len += len;
        }
    }
    
    memcpy(calc_hash, SHA256_final(&ctx), 32);
    
    UDSCFGDebugLog("0x0203: Total length = %x bytes\n", total_len);
    //UDSCFGDebugLog("0x0203: calc_hash= %8x, pDigest= %8x\n", calc_hash, pDigest);
    // 4. 比对摘要值
    if (memcmp(calc_hash, pDigest, 32) == 0) {
        UDSCFGDebugLog("0x0203: Data integrity check PASSED!\n");
        return 0;  // 成功
    } else {
        UDSCFGDebugLog("0x0203: Data integrity check FAILED!\n");
        /* 只置 RAM 的 F1ED，不在回 71 前擦写 NVM，避免上位机等响应超时 */
        FaultInfo_GetPtr()->f1ed |= F1ED_BIT_INTEGRITY_FAIL;

        return -1;  // 失败
    }
}

/* 摘要如何使用，示例 ：在 0x31 0x0203 中使用
if (TRUE == UDS_APP_CheckDataIntegrity(pMsg))
{
    uint8_t* pDigest;
    uint8_t calc_hash[32] = {0};
    struct sha256_ctx ctx;

    // 从 RAM 中获取验签时保存的摘要值 
    pDigest = UDS_Verify_GetSavedDigest();
    if (pDigest == NULL) {
        UDS_APP_AssignNegErrCode(pSrv->serviceId, E_NRC_CONDITIONS_NOT_CORRECT, pMsg);
        return;
    }

    // 计算已下载数据的 SHA256 
    SHA256_init(&ctx);
    SHA256_update(&ctx, (uint8_t*)DOWNLOAD_START_ADDR, DOWNLOAD_DATA_LEN);
    memcpy(calc_hash, SHA256_final(&ctx), 32);

    if (memcmp(calc_hash, pDigest, 32) == 0) {
        // 通过
        // ...
        // 刷写成功后，可以选择清空摘要值 
        // UDS_Verify_ClearDigest();
    } else {
        // 失败，存储失败状态到 DID F1ED（写入 NVM）
        // WriteDID_F1ED(0x02);
    }
    return;
}


// ============================================================
// 示例数据（来自 main.c 和 安全刷写示例数据.txt）
// ============================================================

// 1. CA公钥（示例，256字节）
static const uint8_t g_ca_public_key1[256] = {
    0xd6,0x2f,0xda,0x56,0x1f,0x58,0x7b,0xf1,0xa0,0xf8,0xd2,0x92,0xfe,0xdc,0xea,0x8a,
    0x7b,0xdf,0xeb,0x69,0x86,0xc6,0xc8,0xf1,0x4c,0x95,0xda,0x3e,0x89,0xa4,0xe3,0xc3,
    0x63,0x04,0xaa,0x75,0x9d,0xe6,0x8d,0x38,0x80,0x7b,0x09,0xf2,0x37,0x15,0xb3,0x4d,
    0xc8,0xbc,0xe4,0x12,0xf1,0xa2,0xe1,0xf6,0x00,0xb3,0x8f,0xd0,0x21,0x3f,0xd1,0xcc,
    0xb6,0xb4,0x7f,0xea,0x89,0x0c,0x30,0xd4,0xb1,0x78,0xa0,0xfa,0x10,0xcc,0x2f,0x7e,
    0xab,0x34,0x13,0x97,0xac,0x81,0x7b,0x80,0x77,0x6e,0x83,0x3f,0x87,0xab,0xf1,0x0f,
    0x95,0x8d,0xe1,0xb6,0x21,0x80,0xad,0x04,0xbe,0x1f,0x7b,0x2e,0xbc,0x56,0x72,0x17,
    0xc0,0x2c,0xbd,0xaf,0x02,0x05,0xc0,0x59,0x0a,0x5c,0xd3,0xbe,0x0c,0x31,0x6e,0x82,
    0xf6,0x2e,0xf9,0xec,0x97,0x94,0x3c,0x05,0x19,0x95,0x7d,0x83,0x20,0x11,0x65,0x52,
    0x74,0x3c,0xca,0x7d,0x2d,0xd4,0xce,0xf6,0xd2,0xcc,0x92,0x06,0x6f,0x6c,0x2a,0x76,
    0xe4,0x47,0x23,0xcf,0x3a,0x2c,0xb3,0xe6,0xfb,0x30,0xb5,0x58,0xa2,0x4f,0x0e,0x84,
    0xa2,0xce,0x18,0x82,0x95,0x2a,0x54,0x1a,0x3d,0x63,0xcc,0x93,0x9c,0x7d,0x90,0xf6,
    0xee,0x37,0xde,0x8d,0xaf,0x40,0xf4,0x25,0x19,0x67,0x4e,0x77,0x72,0x16,0xb7,0x62,
    0x9a,0xe6,0x62,0xdb,0xdb,0xc9,0xea,0x1e,0xd3,0xb3,0x03,0x19,0xd2,0xc3,0xbd,0x90,
    0x54,0xfe,0x17,0xc2,0xc5,0xec,0x5d,0xa1,0xbb,0x47,0x99,0x63,0xe9,0x42,0x49,0x66,
    0xe0,0x25,0x4f,0x97,0x8f,0x02,0xe8,0xca,0x2d,0xed,0xff,0x42,0x11,0xa5,0x93,0x27
};

// 2. X.509证书（来自 T03_ACU0001.cer，980字节，填充0x00至1024字节）
static const uint8_t g_test_certificate[1024] = {
    0x30,0x82,0x03,0xd2,0x30,0x82,0x02,0xba,0xa0,0x03,0x02,0x01,0x02,0x02,0x06,0x7f,
    0xa5,0x3b,0xbb,0x61,0x73,0x30,0x0d,0x06,0x09,0x2a,0x86,0x48,0x86,0xf7,0x0d,0x01,
    0x01,0x0b,0x05,0x00,0x30,0x6c,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,
    0x02,0x63,0x6e,0x31,0x11,0x30,0x0f,0x06,0x03,0x55,0x04,0x08,0x0c,0x08,0x7a,0x68,
    0x65,0x6a,0x69,0x61,0x6e,0x67,0x31,0x11,0x30,0x0f,0x06,0x03,0x55,0x04,0x07,0x0c,
    0x08,0x68,0x61,0x6e,0x67,0x7a,0x68,0x6f,0x75,0x31,0x12,0x30,0x10,0x06,0x03,0x55,
    0x04,0x0a,0x0c,0x09,0x6c,0x65,0x61,0x70,0x6d,0x6f,0x74,0x6f,0x72,0x31,0x0f,0x30,
    0x0d,0x06,0x03,0x55,0x04,0x0b,0x0c,0x06,0x63,0x61,0x72,0x6e,0x65,0x74,0x31,0x12,
    0x30,0x10,0x06,0x03,0x55,0x04,0x03,0x0c,0x09,0x76,0x65,0x68,0x69,0x63,0x6c,0x65,
    0x43,0x41,0x30,0x1e,0x17,0x0d,0x32,0x33,0x30,0x35,0x33,0x31,0x30,0x33,0x33,0x31,
    0x35,0x33,0x5a,0x17,0x0d,0x33,0x33,0x30,0x35,0x32,0x38,0x30,0x33,0x33,0x31,0x35,
    0x33,0x5a,0x30,0x81,0xa2,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,
    0x63,0x6e,0x31,0x11,0x30,0x0f,0x06,0x03,0x55,0x04,0x08,0x0c,0x08,0x7a,0x68,0x65,
    0x6a,0x69,0x61,0x6e,0x67,0x31,0x11,0x30,0x0f,0x06,0x03,0x55,0x04,0x07,0x0c,0x08,
    0x68,0x61,0x6e,0x67,0x7a,0x68,0x6f,0x75,0x31,0x12,0x30,0x10,0x06,0x03,0x55,0x04,
    0x0a,0x0c,0x09,0x6c,0x65,0x61,0x70,0x6d,0x6f,0x74,0x6f,0x72,0x31,0x0f,0x30,0x0d,
    0x06,0x03,0x55,0x04,0x0b,0x0c,0x06,0x63,0x61,0x72,0x6e,0x65,0x74,0x31,0x15,0x30,
    0x13,0x06,0x03,0x55,0x04,0x0c,0x0c,0x0c,0x53,0x65,0x63,0x75,0x72,0x69,0x74,0x79,
    0x42,0x6f,0x6f,0x74,0x31,0x14,0x30,0x12,0x06,0x03,0x55,0x04,0x03,0x0c,0x0b,0x54,
    0x30,0x33,0x5f,0x41,0x43,0x55,0x30,0x30,0x30,0x31,0x31,0x1b,0x30,0x19,0x06,0x0a,
    0x09,0x92,0x26,0x89,0x93,0xf2,0x2c,0x64,0x01,0x01,0x0c,0x0b,0x54,0x30,0x33,0x5f,
    0x41,0x43,0x55,0x42,0x6f,0x6f,0x74,0x30,0x82,0x01,0x22,0x30,0x0d,0x06,0x09,0x2a,
    0x86,0x48,0x86,0xf7,0x0d,0x01,0x01,0x01,0x05,0x00,0x03,0x82,0x01,0x0f,0x00,0x30,
    0x82,0x01,0x0a,0x02,0x82,0x01,0x01,0x00,0xce,0x84,0xaa,0x04,0x39,0x05,0x0b,0x85,
    0xa8,0x11,0xce,0xf8,0xd1,0xa2,0x03,0xe1,0x04,0xd3,0xf5,0xf3,0x5b,0x3b,0x88,0x3d,
    0xd5,0x82,0xce,0x9d,0xf2,0x3e,0x10,0x5c,0x81,0xa6,0x4e,0x93,0x8b,0x27,0x21,0xf7,
    0xee,0xbe,0xc9,0x44,0x06,0x70,0x54,0xd6,0x9b,0x15,0xd5,0xaf,0xed,0x17,0xa9,0x73,
    0xe8,0x8b,0xeb,0x79,0x85,0x28,0x5e,0x08,0x25,0x6b,0xc9,0x3c,0xed,0x51,0xbf,0xa7,
    0x9b,0x8c,0xe8,0x9e,0x48,0x11,0xf5,0x7a,0x70,0x23,0x6b,0x04,0x48,0x1c,0xe7,0xa8,
    0xf9,0xb3,0x9a,0xee,0x62,0x1b,0x3a,0x45,0xf1,0x06,0x79,0xcf,0x63,0x93,0x0b,0x3e,
    0xd3,0x87,0x96,0x5d,0xda,0x6e,0x73,0x79,0x22,0x7f,0x40,0x92,0xa5,0x6f,0x35,0xa3,
    0x1b,0xb7,0xf7,0x6c,0x62,0x4d,0x68,0xec,0xf0,0x90,0x26,0x12,0xd4,0xcd,0x0e,0x95,
    0x8b,0x20,0x6d,0x72,0x6d,0x8b,0x89,0xf5,0x92,0x29,0xda,0xd1,0x67,0x19,0x37,0x2c,
    0x06,0xcc,0x15,0xa4,0xc4,0xaf,0x41,0xfb,0xc4,0x5f,0x92,0x08,0x25,0x09,0x33,0x83,
    0x30,0xfe,0x7e,0x71,0xc5,0xc5,0x46,0x96,0xc6,0xd8,0xf4,0x6f,0x4a,0x31,0x75,0xe7,
    0x37,0x26,0xc5,0x8d,0x5f,0x42,0x2b,0xa3,0x52,0x96,0x1b,0x3d,0x67,0xc3,0x4e,0x4f,
    0x7a,0xdc,0x06,0xc7,0x97,0xf1,0xf0,0x66,0x03,0x3b,0x54,0x7d,0x1f,0x1a,0xa0,0x20,
    0x22,0x82,0xa8,0x52,0x0f,0x1a,0xb8,0x1d,0xc5,0x0f,0xb0,0x06,0x58,0x3e,0x89,0xed,
    0x12,0xd5,0xaa,0xfe,0x1c,0x43,0x04,0x0c,0x8d,0x49,0x09,0x34,0x79,0x2b,0x9f,0xa1,
    0xf1,0x42,0x3f,0xe8,0x74,0x9f,0xe2,0x95,0x02,0x03,0x01,0x00,0x01,0xa3,0x43,0x30,
    0x41,0x30,0x09,0x06,0x03,0x55,0x1d,0x13,0x04,0x02,0x30,0x00,0x30,0x0b,0x06,0x03,
    0x55,0x1d,0x0f,0x04,0x04,0x03,0x02,0x01,0xbe,0x30,0x27,0x06,0x03,0x55,0x1d,0x25,
    0x04,0x20,0x30,0x1e,0x06,0x08,0x2b,0x06,0x01,0x05,0x05,0x07,0x03,0x01,0x06,0x08,
    0x2b,0x06,0x01,0x05,0x05,0x07,0x03,0x02,0x06,0x08,0x2b,0x06,0x01,0x05,0x05,0x07,
    0x03,0x03,0x30,0x0d,0x06,0x09,0x2a,0x86,0x48,0x86,0xf7,0x0d,0x01,0x01,0x0b,0x05,
    0x00,0x03,0x82,0x01,0x01,0x00,0x4f,0xef,0x19,0x00,0xed,0xff,0x81,0xef,0x7f,0x0a,
    0x3d,0xe1,0xb9,0xe3,0xa6,0xf8,0x50,0x62,0x41,0x97,0x0d,0xc6,0x1c,0x38,0x34,0xff,
    0x1e,0x13,0x51,0xaa,0xe9,0x35,0x8c,0x8b,0x10,0x33,0xf1,0x54,0xac,0x86,0xd9,0x8a,
    0x65,0xd9,0x06,0x8d,0x05,0x41,0xd6,0x41,0x93,0x76,0x65,0x6a,0x35,0x55,0x5b,0xaf,
    0x8f,0x32,0x2b,0xd1,0x64,0x73,0x74,0xa8,0x5f,0x50,0x9a,0x4a,0xe6,0xc0,0x73,0xf0,
    0x54,0xb8,0xe7,0x6b,0xa7,0x3d,0x08,0xe3,0xf8,0x4c,0x9b,0x3e,0xee,0x64,0x47,0x76,
    0xfb,0xf6,0x47,0x88,0x38,0x41,0xf4,0x73,0x81,0x32,0x95,0x15,0x08,0x89,0x37,0x15,
    0x38,0x41,0xf7,0xdf,0x77,0x55,0x4b,0xc2,0x5c,0xa2,0xe4,0x8f,0xdc,0x63,0xea,0xcc,
    0xc2,0x9f,0x94,0xc8,0x60,0xce,0xe7,0xd9,0xa8,0xf2,0xbc,0x24,0x47,0xca,0x0a,0x6e,
    0x07,0xae,0x5e,0x02,0xdd,0xdd,0x06,0x8e,0x0d,0x8c,0x4c,0x7e,0xbc,0xd1,0x3b,0xe2,
    0xa2,0x75,0x33,0x88,0x25,0x22,0x6a,0x38,0xb1,0x40,0xf3,0x09,0x3d,0xb9,0xc5,0x0e,
    0x91,0xf2,0xb4,0x01,0xbc,0x6a,0x19,0x28,0xc3,0xff,0xa8,0xd8,0x46,0xf4,0xe2,0x89,
    0xda,0x6c,0x9a,0xa8,0xb4,0xa8,0x60,0x53,0xc1,0xf5,0xd7,0xa9,0x2e,0x32,0xfe,0x8d,
    0x14,0x18,0xce,0x3f,0x0d,0xe3,0x7a,0x36,0x79,0x23,0xc3,0x08,0xd1,0x29,0xb5,0xb8,
    0x9e,0x1c,0xfb,0xa3,0x74,0xef,0xc4,0x44,0x2f,0x8f,0x35,0x0b,0xea,0xec,0xe8,0x13,
    0x37,0xc1,0x35,0xcb,0x86,0x93,0x73,0x11,0xb0,0x4b,0x7f,0x1e,0xde,0x15,0x7f,0xad,
    0x1c,0xc9,0x3e,0xe9,0xe5,0x14,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};

// 3. 模块数据摘要值（固件 SHA256）
static const uint8_t g_test_hash_data[32] = {
    0x20,0x5c,0x07,0x8d,0xfc,0xf3,0x52,0x19,0xa2,0xdd,0xe8,0x3e,0xe5,0xd1,0x37,0xc0,
    0xf8,0x7c,0x5e,0x83,0xb0,0xc6,0xac,0xe5,0x01,0xea,0x2e,0xf0,0xa5,0x42,0x86,0x47
};

// 4. 版本信息（10字节）
static const uint8_t g_test_version_data[10] = {
    0x31,0x30,0x30,0x30,0x31,0x31,0x31,0x31,0x38,0x30
};

// 5. 文件头签名值（256字节）
static const uint8_t g_test_sign_data[256] = {
    0x88,0x5c,0x2a,0x60,0x7a,0xdf,0x41,0x1a,0x5e,0x58,0x1b,0xc0,0xd7,0xcd,0xde,0x21,
    0x2e,0xdc,0xaf,0x54,0xfc,0x54,0x0a,0xfe,0x86,0x30,0xb5,0xd0,0xf7,0x37,0x4b,0x89,
    0x7b,0x5c,0x7a,0xaf,0x73,0x23,0xd7,0xdc,0x29,0x42,0xeb,0xd2,0xdc,0xa3,0xa7,0x55,
    0x08,0x4f,0x3b,0xcd,0x52,0x38,0xbe,0xfe,0xcc,0x7f,0xfa,0xd4,0xcb,0xc8,0xfe,0xb5,
    0x72,0x82,0xbd,0xe8,0xac,0xd9,0x7d,0xbe,0x28,0x00,0xdc,0xed,0xd1,0x9d,0xd3,0x75,
    0x22,0x38,0x5c,0xae,0xb4,0x5f,0xa5,0x75,0x85,0xb4,0xdd,0x6f,0xa4,0x17,0x9f,0xad,
    0x87,0x66,0xbf,0xa5,0x96,0x5e,0xa3,0xc0,0xa4,0xd1,0xa0,0x3e,0xfd,0x5c,0x07,0x50,
    0xb3,0x27,0x0b,0xfd,0x4b,0x7a,0xe9,0x99,0x45,0x3e,0x0a,0x48,0xb8,0x26,0xf5,0xa8,
    0x46,0x0a,0x49,0x84,0x6f,0x87,0x44,0x0c,0x84,0x48,0xc7,0x6f,0x1b,0xcb,0x7d,0x6e,
    0xdd,0xa7,0x76,0x0e,0x85,0x10,0x7b,0x1c,0xfd,0x98,0x40,0x47,0xb7,0x14,0x82,0x16,
    0x7c,0x09,0x0f,0x0e,0x9b,0x62,0x91,0xb5,0x90,0x44,0x0d,0x15,0x4d,0x84,0xe1,0x70,
    0x74,0x96,0xd9,0xfa,0xf5,0x51,0xd2,0xdf,0x62,0x86,0xb5,0xd6,0x65,0x10,0x0a,0xc1,
    0x79,0x87,0xae,0xc9,0x42,0x89,0xa9,0x35,0xb1,0x5d,0xb4,0x4f,0xe5,0x5c,0x73,0x3e,
    0x75,0x1a,0xca,0xa7,0x8c,0x0b,0xd6,0x5d,0xff,0xca,0x34,0x39,0x0c,0x1e,0x67,0x5f,
    0xff,0x35,0xd3,0xe8,0xf0,0x5b,0x03,0xaf,0x19,0x9a,0x7d,0x6f,0x0d,0x34,0xb2,0xbb,
    0x49,0x29,0x24,0x0c,0x9b,0x86,0x65,0x05,0x31,0xec,0x55,0xb8,0x9a,0x4d,0xce,0xd8
};

// 6. 固件原文（208字节）
static const uint8_t g_test_firmware_data[208] = {
    0x1e,0x13,0x51,0xaa,0xe9,0x35,0x8c,0x8b,0x10,0x33,0xf1,0x54,0xac,0x86,0xd9,0x8a,
    0x65,0xd9,0x06,0x8d,0x05,0x41,0xd6,0x41,0x93,0x76,0x65,0x6a,0x35,0x55,0x5b,0xaf,
    0x8f,0x32,0x2b,0xd1,0x64,0x73,0x74,0xa8,0x5f,0x50,0x9a,0x4a,0xe6,0xc0,0x73,0xf0,
    0x54,0xb8,0xe7,0x6b,0xa7,0x3d,0x08,0xe3,0xf8,0x4c,0x9b,0x3e,0xee,0x64,0x47,0x76,
    0xfb,0xf6,0x47,0x88,0x38,0x41,0xf4,0x73,0x81,0x32,0x95,0x15,0x08,0x89,0x37,0x15,
    0x38,0x41,0xf7,0xdf,0x77,0x55,0x4b,0xc2,0x5c,0xa2,0xe4,0x8f,0xdc,0x63,0xea,0xcc,
    0xc2,0x9f,0x94,0xc8,0x60,0xce,0xe7,0xd9,0xa8,0xf2,0xbc,0x24,0x47,0xca,0x0a,0x6e,
    0x07,0xae,0x5e,0x02,0xdd,0xdd,0x06,0x8e,0x0d,0x8c,0x4c,0x7e,0xbc,0xd1,0x3b,0xe2,
    0xa2,0x75,0x33,0x88,0x25,0x22,0x6a,0x38,0xb1,0x40,0xf3,0x09,0x3d,0xb9,0xc5,0x0e,
    0x91,0xf2,0xb4,0x01,0xbc,0x6a,0x19,0x28,0xc3,0xff,0xa8,0xd8,0x46,0xf4,0xe2,0x89,
    0xda,0x6c,0x9a,0xa8,0xb4,0xa8,0x60,0x53,0xc1,0xf5,0xd7,0xa9,0x2e,0x32,0xfe,0x8d,
    0x14,0x18,0xce,0x3f,0x0d,0xe3,0x7a,0x36,0x79,0x23,0xc3,0x08,0xd1,0x29,0xb5,0xb8,
    0x9e,0x1c,0xfb,0xa3,0x74,0xef,0xc4,0x44,0x2f,0x8f,0x35,0x0b,0xea,0xec,0xe8,0x13
};

// ============================================================
// 测试结构体（模拟 0x31 0x6000 发来的 1322 字节数据）
// ============================================================
//typedef struct {
//    uint8_t data_digest[32];
//    uint8_t certificate[1024];
//    uint8_t version_info[10];
//    uint8_t signature[256];
//} UDS_VerifyParamType;  // 总计 1322 字节

// ============================================================
// 测试函数
// ============================================================
static void PrintBuff1(char *title, const unsigned char *src, const unsigned int size)
{
    unsigned int i = 0;
    UDSCFGDebugLog("===============:%s:%d=====================\n", title, size);
    for (i = 0; i < size; i++) {
        UDSCFGDebugLog("0x%02x%c", src[i], ((i + 1) % 16) ? ' ' : '\n');
    }
    UDSCFGDebugLog("\n==========================================\n");
}

int verify_sign_info1(const uint8_t *sign_info)  //验证通过
{
    int ret;
    rsa_pk_t ca_pk = {0};
    rsa_pk_t cert_pk = {0};
    cont sig = {0};
    cont hash = {0};
    cont m = {0};
    cont e = {0};
    uint8_t dec_sign[256] = {0};
    uint8_t sha256_calc[32] = {0};
    uint32_t dec_sign_len = 0;
    struct sha256_ctx ctx = {0};
    int err = 0;
    
    UDSCFGDebugLog("\n============================================================\n");
    UDSCFGDebugLog("============================================================\n\n");
    
    // ============================================================
    // 子步骤1：验证证书合法性
    // ============================================================
    UDSCFGDebugLog("[步骤1] 验证证书合法性\n");
    UDSCFGDebugLog("------------------------------------------------------------\n");
    
    // 1.1 计算证书 TBS 的 SHA256 
    err = calc_cert_sha256(g_test_certificate, 1024, sha256_calc);
    if (err != 0) {
        UDSCFGDebugLog("calc_cert_sha256 失败\n");
        return -1;
    }
    UDSCFGDebugLog("1.1 TBSCertificate SHA256 计算成功\n");
    
    // 1.2 从证书中提取 signatureValue 
    err = get_x509_signature(g_test_certificate, 1024, &sig);
    if (err != 0) {
        UDSCFGDebugLog("get_x509_signature 失败\n");
        return -1;
    }
    UDSCFGDebugLog("1.2 从证书中提取 signatureValue 成功，长度: %d 字节\n", sig.len);
    
    // 1.3 用 CA 公钥解密证书签名值 
    ca_pk.bits = 2048;
    memcpy(ca_pk.m, g_ca_public_key1, 256);
    ca_pk.e[253] = 0x01;
    ca_pk.e[254] = 0x00;
    ca_pk.e[255] = 0x01;
    
    err = rsa_public_decrypt(dec_sign, &dec_sign_len, (uint8_t *)sig.addr, sig.len, &ca_pk);
    if (err != 0) {
        UDSCFGDebugLog("rsa_public_decrypt 失败: 0x%04x\n", err);
        return -1;
    }
    UDSCFGDebugLog("1.3 用 CA 公钥解密签名值成功，长度: %d 字节\n", dec_sign_len);
    
    // 1.4 从解密后的签名中提取哈希值 
    err = get_hash_from_signature(dec_sign, dec_sign_len, &hash);
    if (err != 0) {
        UDSCFGDebugLog("get_hash_from_signature 失败\n");
        return -1;
    }
    UDSCFGDebugLog("1.4 从解密签名中提取哈希值成功\n");
    
    // 1.5 比对哈希值 
    if (memcmp(hash.addr, sha256_calc, 32) != 0) {
        UDSCFGDebugLog("1.5  哈希值不匹配！证书无效！\n");
        return -1;
    }
    UDSCFGDebugLog("1.5  哈希值匹配！证书由 CA 签发\n\n");
    
    // ============================================================
    // 子步骤2：验证文件头签名
    // ============================================================
    UDSCFGDebugLog("[步骤2] 验证文件头签名\n");
    UDSCFGDebugLog("------------------------------------------------------------\n");
    
    // 2.1 从证书中提取公钥 
    err = get_x509_pkey(g_test_certificate, 1024, &m, &e);
    if (err != 0) {
        UDSCFGDebugLog("get_x509_pkey 失败\n");
        return -1;
    }
    UDSCFGDebugLog("2.1 从证书中提取公钥成功,m.len=%d, e.len=%d\n", m.len, e.len);
    
    // 2.2 构造证书公钥 
    cert_pk.bits = 2048;
    memcpy(cert_pk.m, m.addr, m.len);
    memcpy(&cert_pk.e[RSA_MAX_MODULUS_LEN - e.len], e.addr, e.len);
    UDSCFGDebugLog("2.2 证书公钥构造完成\n");
    
    // 2.3 计算 (data_digest + certificate + version_info) 的 SHA256 
    SHA256_init(&ctx);
    SHA256_update(&ctx, g_test_hash_data, 32);
    SHA256_update(&ctx, g_test_certificate, 1024);
    SHA256_update(&ctx, g_test_version_data, 10);
    memcpy(sha256_calc, SHA256_final(&ctx), 32);
    UDSCFGDebugLog("2.3 计算 (摘要+证书+版本) 的 SHA256 成功\n");
    
    // 2.4 用证书公钥解密文件头签名值 
    err = rsa_public_decrypt(dec_sign, &dec_sign_len, (uint8_t *)g_test_sign_data, 256, &cert_pk);
    if (err != 0) {
        UDSCFGDebugLog("rsa_public_decrypt 失败: 0x%04x\n", err);
        return -1;
    }
    UDSCFGDebugLog("2.4 用证书公钥解密文件头签名值成功，长度: %d 字节\n", dec_sign_len);
    
    // 2.5 从解密后的签名中提取哈希值 
    err = get_hash_from_signature(dec_sign, dec_sign_len, &hash);
    if (err != 0) {
        UDSCFGDebugLog("get_hash_from_signature 失败\n");
        return -1;
    }
    UDSCFGDebugLog("2.5 从解密签名中提取哈希值成功\n");
    
    // 2.6 比对哈希值 
    if (memcmp(hash.addr, sha256_calc, 32) != 0) {
        UDSCFGDebugLog("2.6  哈希值不匹配！签名无效！\n");
        return -1;
    }
    UDSCFGDebugLog("2.6  哈希值匹配！文件头签名验证通过\n\n");
    
    // ============================================================
    // 子步骤3：验证固件哈希（可选）
    // ============================================================
    UDSCFGDebugLog("[步骤3] 验证固件哈希（可选）\n");
    UDSCFGDebugLog("------------------------------------------------------------\n");
    
    SHA256_init(&ctx);
    SHA256_update(&ctx, g_test_firmware_data, sizeof(g_test_firmware_data));
    if (memcmp(SHA256_final(&ctx), g_test_hash_data, 32) != 0) {
        UDSCFGDebugLog("3.0  固件哈希不匹配\n");
    } else {
        UDSCFGDebugLog("3.0  固件哈希匹配\n\n");
    }
    
    // ============================================================
    // 最终结果
    // ============================================================
    UDSCFGDebugLog("============================================================\n");
    UDSCFGDebugLog("? 所有验证通过！\n");
    UDSCFGDebugLog("============================================================\n");
    
    PrintBuff1("证书公钥 m", m.addr, 32);
    PrintBuff1("解密哈希值", hash.addr, 32);
    PrintBuff1("计算哈希值", sha256_calc, 32);
    
    return 0;
}

*/



