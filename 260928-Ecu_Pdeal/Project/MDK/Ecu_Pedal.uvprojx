# Keil uVision project Ecu_Pedal.uvprojx, settings and files
target G32A10xx (6160000::V6.16::ARMCLANG)
  device: G32A1085MAT0MLHx Geehy
  pack: Geehy.G32A10xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf.exe --bin --output "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BOARD_G32A10xx_EVAL,G32A10xx,UDS_PROJECT_FOR_APP
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\Device\Geehy\G32A10xx\Include;..\..\Libraries\G32A10xx_StdPeriphDriver\inc;..\..\Driver\include;..\..\Hal\include;..\..\Application\include;..\..\Common;..\..\CanNm\include;..\..\Uds\Port;..\..\Uds\TP\inc;..\..\Uds\TP\inc\CAN_TP;..\..\Uds\UDS\inc;..\..\Uds\FIFO\inc;..\..\Uds\auto_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x800f800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Libraries/Device/Geehy/G32A10xx/Source/: system_g32a10xx.c
    ../../Libraries/Device/Geehy/G32A10xx/Source/arm/: startup_g32a10xx_mdk.s
  group Application
    ../../Application/source/: main.c g32a10xx_int.c app_canfd.c app_timer.c app_power.c app_led.c app_pedal.c app_motor.c app_usart.c
  group Hal
    ../../Application/include/: board.h
    ../../Hal/source/: hal_adc.c hal_usart.c hal_dma.c hal_canfd.c hal_timer.c hal_led.c hal_buzzer.c hal_motor.c hal_drv8718.c hal_pmu.c hal_iwdt.c hal_rtc.c
    ../../Application/source/: fifo.c
  group Driver
    ../../Driver/source/: drv_spi.c drv_adc.c drv_gpio.c drv_dma.c drv_usart.c drv_canfd.c drv_tmr_base.c drv_tmr_pwm.c drv_eint.c drv_pmu.c drv_iwdt.c drv_rtc.c
  group Std
    ../../Libraries/G32A10xx_StdPeriphDriver/src/: g32a10xx_adc.c g32a10xx_can.c g32a10xx_gpio.c g32a10xx_iwdt.c g32a10xx_rcm.c g32a10xx_tmr.c g32a10xx_usart.c g32a10xx_spi.c g32a10xx_misc.c g32a10xx_dma.c g32a10xx_syscfg.c g32a10xx_eint.c g32a10xx_pmu.c g32a10xx_fls.c g32a10xx_rtc.c
  group Uds
    ../../Uds/Port/: uds_port.c uds_can_if.c uds_stub.c user_versions.c uds_dtc_nvm.c uds_port.h uds_can_if.h includes.h user_config.h common_types.h toolchain.h user_versions.h boot.h boot_Cfg.h fls_app.h CRC_hal.h watchdog_hal.h uds_alg_hal.h uds_verify.h flash_hal_Cfg.h bootloader_debug.h
    ../../Uds/UDS/src/: uds_app.c uds_app_cfg.c
    ../../Uds/TP/src/: TP.c TP_Cfg.c
    ../../Uds/TP/src/CAN_TP/: can_tp.c can_tp_cfg.c
    ../../Uds/FIFO/src/: multi_cyc_fifo.c
    ../../Uds/auto_lib/src/: autolibc.c
    ../../Uds/UDS/inc/: uds_app.h uds_app_cfg.h uds_dtc_nvm.h
    ../../Uds/TP/inc/: TP.h TP_cfg.h
    ../../Uds/TP/inc/CAN_TP/: can_tp.h can_tp_cfg.h
    ../../Uds/FIFO/inc/: multi_cyc_fifo.h
    ../../Uds/auto_lib/inc/: autolibc.h
  group CanNm
    ../../CanNm/source/: CanNm.c CanNm_Cbk.c CanNm_Lcfg.c CanNm_Pnc.c
