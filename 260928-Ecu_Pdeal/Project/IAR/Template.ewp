# IAR project Template.ewp, settings and files
configuration G32A10xx (ARM, debug)
  General.OGChipSelectEditMenu: G32A1085 Geehy G32A1085
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_G32A10xx_EVAL; G32A10xx
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\G32A10xx_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\G32A10xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: g32a10xx_int.c main.c
  group Board
    ../../../../../../Boards/: Board.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/G32A10xx/Source/iar/: startup_g32a10xx_iar.s
    ../../../../../../Libraries/Device/Geehy/G32A10xx/Source/: system_g32a10xx.c
  group StdPeriphDriver
    ../../../../../../Libraries/G32A10xx_StdPeriphDriver/src/: g32a10xx_adc.c g32a10xx_crc.c g32a10xx_dbgmcu.c g32a10xx_dma.c g32a10xx_eint.c g32a10xx_fls.c g32a10xx_gpio.c g32a10xx_iwdt.c g32a10xx_misc.c g32a10xx_pmu.c g32a10xx_rcm.c g32a10xx_rtc.c g32a10xx_spi.c g32a10xx_syscfg.c g32a10xx_tmr.c g32a10xx_usart.c
