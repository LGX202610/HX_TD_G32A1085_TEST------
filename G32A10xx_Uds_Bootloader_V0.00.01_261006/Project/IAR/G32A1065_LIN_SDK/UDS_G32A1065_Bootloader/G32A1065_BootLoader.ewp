# IAR project G32A1065_BootLoader.ewp, settings and files
configuration G32A1065 (ARM, debug)
  General.OGChipSelectEditMenu: G32A1065 Geehy G32A1065
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; G32A10xx; G32A1065; START_FROM_FLASH; TURN_ON_CPU0; UDS_PROJECT_FOR_BOOTLOADER; AUTOSAR_OS_NOT_USED
  ICCARM.CCIncludePath2: ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\devices\CMSIS\Include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\devices\Include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Flash\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Flash_UpLayerDriver\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Gpio\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Interrupt\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Lin\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Misc\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Rcm\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Tmr\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Usart\include; ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Wdg\include; ..\..\..\..\Porting\SDK\G32A10xx_LIN\boot\inc; ..\..\..\..\Porting\SDK\G32A10xx_LIN\Debug\inc; ..\..\..\..\Porting\SDK\G32A10xx_LIN\HAL\crc_hal\inc; ..\..\..\..\Porting\SDK\G32A10xx_LIN\HAL\flash_hal\inc; ..\..\..\..\Porting\SDK\G32A10xx_LIN\HAL\timer_hal\inc; ..\..\..\..\Porting\SDK\G32A10xx_LIN\HAL\UDS_algorithm_hal\inc; ..\..\..\..\Porting\SDK\G32A10xx_LIN\HAL\watchdog_hal\inc; ..\..\..\..\Porting\SDK\G32A10xx_LIN\public_inc; ..\..\..\..\UDS_stack\unified_bootloader_stack\Source\auto_lib\inc; ..\..\..\..\UDS_stack\unified_bootloader_stack\Source\Demo\inc; ..\..\..\..\UDS_stack\unified_bootloader_stack\Source\FIFO\inc; ..\..\..\..\UDS_stack\unified_bootloader_stack\Source\Flash_App\inc; ..\..\..\..\UDS_stack\unified_bootloader_stack\Source\UDS_stack\TP\inc; ..\..\..\..\UDS_stack\unified_bootloader_stack\Source\UDS_stack\TP\inc\LIN_TP; ..\..\..\..\UDS_stack\unified_bootloader_stack\Source\UDS_stack\UDS\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: START_FROM_FLASH; TURN_ON_CPU0; UDS_PROJECT_FOR_BOOTLOADER
  AARM.AUserIncludes: SEGGER_RTT\include
  OBJCOPY.OOCOutputFile: UDS_G32A1065_Bootloader.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.elf
  ILINK.IlinkIcfFile: ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\devices\link\iar\iar_flash_g32a1065_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AUTOSAR_OS_NOT_USED; IAR; G32A1065
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\Platform_TS_T23D06M1I0R0\include; ..\..\..\Det_TS_T23D06M1I0R0\include; ..\..\..\Rte_TS_T23D06M1I0R0\include; ..\..\..\Dem_TS_T23D06M1I0R0\include; $TOOLKIT_DIR$\CMSIS\Core\Include; ..\..\..\Port_TS_T23D06M1I0R0\include; ..\..\..\Dio_TS_T23D06M1I0R0\include; ..\..\..\Mcu_TS_T23D06M1I0R0\include; Application\include; ..\..\..\Platform_TS_T23D06M1I0R0\startup\include; Config\include; ..\..\..\Pdl_TS_T23D06M1I0R0\include
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Adc_ITA.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\Platform_TS_T23D06M1I0R0\Startup\link\autosar_flash_g32a1465.icf
  ILINK.IlinkProgramEntryLabel: _start
  group Application
    Application/src/: main.c
  group Platform
    ../../../../Porting/SDK/G32A10xx_SDK/platform/devices/Source/iar/: startup_g32a10xx_iar.s
    ../../../../Porting/SDK/G32A10xx_SDK/platform/devices/Source/: system_g32a10xx.c
  group Sdk
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Flash_UpLayerDriver/src/: flash.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Flash/src/: g32a10xx_fls.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Gpio/src/: g32a10xx_gpio.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Interrupt/src/: g32a10xx_int.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Wdg/src/: g32a10xx_iwdt.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Misc/src/: g32a10xx_misc.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Rcm/src/: g32a10xx_rcm.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Tmr/src/: g32a10xx_tmr.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Usart/src/: g32a10xx_usart.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Lin/src/: lin_app.c
  group Uds_PortingFiles/Boot
    ../../../../Porting/SDK/G32A10xx_LIN/boot/src/: boot.c boot_Cfg.c
  group Uds_PortingFiles/Debug
    ../../../../Porting/SDK/G32A10xx_LIN/Debug/src/: bootloader_debug.c debug_IO.c debug_timer.c
  group Uds_PortingFiles/Hal/Crc_Hal
    ../../../../Porting/SDK/G32A10xx_LIN/HAL/crc_hal/src/: CRC_hal.c
  group Uds_PortingFiles/Hal/Flash_Hal
    ../../../../Porting/SDK/G32A10xx_LIN/HAL/flash_hal/src/: flash_hal.c flash_hal_Cfg.c
  group Uds_PortingFiles/Hal/Timer_Hal
    ../../../../Porting/SDK/G32A10xx_LIN/HAL/timer_hal/src/: timer_hal.c
  group Uds_PortingFiles/Hal/Uds_Algorithm_Hal
    ../../../../Porting/SDK/G32A10xx_LIN/HAL/UDS_algorithm_hal/src/: AES.c UDS_alg_hal.c ZLGKey.c
  group Uds_PortingFiles/Hal/Watchdog_Hal
    ../../../../Porting/SDK/G32A10xx_LIN/HAL/watchdog_hal/src/: watchdog_hal.c
  group Uds_Stack/Auto_Lib
    ../../../../UDS_stack/unified_bootloader_stack/Source/auto_lib/src/: autolibc.c
  group Uds_Stack/Demo
    ../../../../UDS_stack/unified_bootloader_stack/Source/Demo/src/: bootloader_main.c
  group Uds_Stack/Fifo
    ../../../../UDS_stack/unified_bootloader_stack/Source/FIFO/src/: multi_cyc_fifo.c
  group Uds_Stack/Flash_App
    ../../../../UDS_stack/unified_bootloader_stack/Source/Flash_App/src/: fls_app.c
  group Uds_Stack/Lin_Tp
    ../../../../UDS_stack/unified_bootloader_stack/Source/UDS_stack/TP/src/LIN_TP/: LIN_tp.c LIN_tp_cfg.c
    ../../../../UDS_stack/unified_bootloader_stack/Source/UDS_stack/TP/src/: TP.c TP_Cfg.c
  group Uds_Stack/Uds
    ../../../../UDS_stack/unified_bootloader_stack/Source/UDS_stack/UDS/src/: uds_app.c uds_app_cfg.c
