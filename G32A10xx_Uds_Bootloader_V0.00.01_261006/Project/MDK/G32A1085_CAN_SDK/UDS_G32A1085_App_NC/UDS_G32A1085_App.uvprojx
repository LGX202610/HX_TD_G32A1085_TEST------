# Keil uVision project UDS_G32A1085_App.uvprojx, settings and files
target G32A1085 (6160000::V6.16::ARMCLANG)
  device: G32A1085MAT0MLHx Geehy
  pack: Geehy.G32A10xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UDS_G32A1085_App +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: G32A1085,G32A10xx,G32A10x_SERIES,START_FROM_FLASH,TURN_ON_CPU0,UDS_PROJECT_FOR_APP,APP_A
  c misc: -fno-inline
  c include: ..\..\..\..\Porting\Boot\inc;..\..\..\..\Porting\Debug\inc;..\..\..\..\Porting\Hal\Crc_Hal\inc;..\..\..\..\Porting\Hal\Flash_Hal\inc;..\..\..\..\Porting\Hal\Timer_Hal\inc;..\..\..\..\Porting\Hal\Uds_Algorithm_Hal\inc;..\..\..\..\Porting\Hal\Watchdog_Hal\inc;..\..\..\..\Porting\Public_Inc;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\devices\CMSIS\Include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\devices\Include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Can\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Can_UpLayerDriver\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Flash_UpLayerDriver\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Gpio\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Interrupt\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Rcm\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Tmr\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Usart\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Wdg\include;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\auto_lib\inc;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\Demo\inc;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\FIFO\inc;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\Flash_App\inc;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\UDS_stack\TP\inc\CAN_TP;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\UDS_stack\TP\inc;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\UDS_stack\UDS\inc;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Misc\include;..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\drivers\Flash\include;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\UDS_stack\Versions;..\..\..\..\UDS_stack\unified_bootloader_stack\Source\UDS_stack\EUC_Verify\include
  asm define: UDS_PROJECT_FOR_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x800f800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Porting\SDK\G32A10xx_SDK\platform\devices\link\armc\mdk_flash_g32a1085_app.sct
  link misc: --diag_suppress=6314
  group Application
    ./Application/src/: main.c
  group Startup
    ../../../../Porting/SDK/G32A10xx_SDK/platform/devices/Source/arm/: startup_g32a10xx_mdk.s
    ../../../../Porting/SDK/G32A10xx_SDK/platform/devices/Source/: system_g32a10xx.c
  group UDS_stack
    ../../../../UDS_stack/Unified_Bootloader_Stack/Source/Auto_Lib/src/: autolibc.c
    ../../../../UDS_stack/Unified_Bootloader_Stack/Source/Demo/src/: bootloader_main.c
    ../../../../UDS_stack/Unified_Bootloader_Stack/Source/Fifo/src/: multi_cyc_fifo.c
    ../../../../UDS_stack/Unified_Bootloader_Stack/Source/Flash_App/src/: fls_app.c
    ../../../../UDS_stack/Unified_Bootloader_Stack/Source/Uds_Stack/TP/src/: TP.c TP_Cfg.c
    ../../../../UDS_stack/Unified_Bootloader_Stack/Source/Uds_Stack/TP/src/CAN_TP/: can_tp.c can_tp_cfg.c
    ../../../../UDS_stack/Unified_Bootloader_Stack/Source/Uds_Stack/UDS/src/: uds_app.c uds_app_cfg.c
    ../../../../UDS_stack/unified_bootloader_stack/Source/UDS_stack/Versions/: user_versions.c
    ../../../../UDS_stack/unified_bootloader_stack/Source/UDS_stack/UDS/src/: uds_dtc_nvm.c
  group G32A1085_CAN
    ../../../../Porting/Boot/src/: boot.c boot_Cfg.c
    ../../../../Porting/Debug/src/: bootloader_debug.c debug_IO.c debug_timer.c
    ../../../../Porting/Hal/Crc_Hal/src/: CRC_hal.c
    ../../../../Porting/Hal/Flash_Hal/src/: flash_hal.c flash_hal_Cfg.c
    ../../../../Porting/Hal/Timer_Hal/src/: timer_hal.c
    ../../../../Porting/Hal/Uds_Algorithm_Hal/src/: AES.c UDS_alg_hal.c ZLGKey.c
    ../../../../Porting/Hal/Watchdog_Hal/src/: watchdog_hal.c
  group G32A1085_SDK
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Can/src/: g32a10xx_can.c user_can_config.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Can_UpLayerDriver/src/: can_cfg.c can_driver.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Flash_UpLayerDriver/src/: flash.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Gpio/src/: g32a10xx_gpio.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Interrupt/src/: g32a10xx_int.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Rcm/src/: g32a10xx_rcm.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Tmr/src/: g32a10xx_tmr.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Usart/src/: g32a10xx_usart.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Wdg/src/: g32a10xx_iwdt.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Misc/src/: g32a10xx_misc.c
    ../../../../Porting/SDK/G32A10xx_SDK/platform/drivers/Flash/src/: g32a10xx_fls.c
  group ECU_Verify
    ../../../../UDS_stack/unified_bootloader_stack/Source/UDS_stack/EUC_Verify/source/: bn.c sha256.c uds_verify.c x509.c
